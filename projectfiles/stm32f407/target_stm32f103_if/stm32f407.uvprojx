# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f103c8t6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DAPLINK_VERSION=254, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, OS_TICK=10000, INTERFACE_STM32F407XX, USE_HAL_DRIVER, STM32F407xx, DAPLINK_HIC_ID=0x97969908, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=72000000
  c include: ..\..\..\hic_hal\stm32\stm32f407xx;..\..\..\hic_hal\stm32\stm32f407xx\STM32F4xx_HAL_Driver\Inc;..\..\..\hic_hal\stm32\stm32f407xx\STM32F4xx_HAL_Driver;..\..\..\hic_hal\stm32\stm32f407xx\cmsis;..\..\..\hic_hal;..\..\..\rtos;..\..\..\target;..\..\..\cmsis-core;..\..\..\usb;..\..\..\daplink;..\..\..\daplink\cmsis-dap;..\..\..\daplink\drag-n-drop;..\..\..\daplink\interface;..\..\..\daplink\settings;..\..\..\daplink\usb2uart
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK=10000,-DINTERFACE_STM32F407XX,-DUSE_HAL_DRIVER,-DSTM32F407xx,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000 --no_unaligned_access
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\hic_hal\stm32\stm32f407xx"
  group board
    ../../../board/: stm32f103rb.c
  group cmsis-dap
    ../../../daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    ../../../daplink/interface/: bootloader_update.c daplink.c main.c swd_host.c swd_host_ca.c target_flash.c SVC_Table.s
    ../../../daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group drag-n-drop
    ../../../daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    ../../../family/st/stm32f103rb/: target.c
  group hic_hal
    ../../../hic_hal/stm32/stm32f407xx/armcc/: startup_stm32f407xx.s
    ../../../hic_hal/stm32/stm32f407xx/cmsis/: system_stm32f4xx.c
    ../../../hic_hal/stm32/stm32f407xx/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
    ../../../hic_hal/stm32/stm32f407xx/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c usbd_STM32F407.c
  group rtos
    ../../../rtos/: cmsis_os2_port.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Config.c
    ../../../rtos/cm3/: HAL_CM3.c
  group settings
    ../../../daplink/settings/: settings.c settings_rom.c
  group target
    ../../../target/: target_board.c target_family.c
  group usb
    ../../../usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../../usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../usb/webusb/: usbd_core_webusb.c
    ../../../usb/winusb/: usbd_core_winusb.c
    ../../../usb/: usbd_core.c
  group usb2uart
    ../../../daplink/usb2uart/: usbd_user_cdc_acm.c
